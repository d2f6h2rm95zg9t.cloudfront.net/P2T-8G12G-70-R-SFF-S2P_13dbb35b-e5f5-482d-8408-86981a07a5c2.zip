!Agilent Technologies,N5230C,MY49001174,A.09.42.21
!Agilent N5230C: A.09.42.21
!Date: Saturday, January 30, 2016 08:36:04
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   801 points, 8 GHz to 12 GHz, reference 50 ohm
!   highest |S21| = -80.53 dB at 11.43 GHz (marker M1); lowest = -120.3 dB at 9.45 GHz (marker M2)
!   lowest |S11| = -19.6 dB at 12 GHz (marker M3), VSWR 1.23, Z = 60.6 - j4.71 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -1.3 to -0.8 dB; largest |S21 - S12| = 0.00014
!   S11 on the Smith chart (normalised r, x): 8 GHz: 0.83, -0.13; 9.065 GHz: 0.74, +0.05; 10.25 GHz: 0.83, +0.25; 10.96 GHz: 1.06, +0.40; 11.47 GHz: 1.35, +0.22; 12 GHz: 1.21, -0.09
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 8 GHz  -18.6  -94.1  -110.0  -1.1
! 8.28 GHz  -16.8  -97.7  -90.7  -1.1
! 8.67 GHz  -16.6  -98.3  -95.1  -1.2
! 9.065 GHz  -16.3  -98.5  -117.0  -1.3
! 9.335 GHz  -16.3  -90.5  -93.9  -1.3
! 9.45 GHz  -16.3  -120.3  -107.0  -1.3
! 10 GHz  -15.9  -96.0  -89.9  -1.2
! 10.25 GHz  -15.7  -96.1  -99.1  -1.2
! 10.67 GHz  -14.7  -89.5  -106.3  -1.1
! 10.96 GHz  -14.4  -85.9  -90.5  -1.0
! 11.34 GHz  -14.7  -89.8  -89.1  -0.9
! 11.43 GHz  -15.0  -80.5  -91.0  -0.9
! 11.47 GHz  -15.1  -101.8  -89.4  -0.9
! 11.7 GHz  -16.4  -84.6  -91.2  -0.8
! 11.71 GHz  -16.4  -83.8  -103.3  -0.8
! 11.71 GHz  -16.5  -85.9  -89.0  -0.8
! 11.74 GHz  -16.7  -96.5  -89.7  -0.8
! 11.75 GHz  -16.8  -93.7  -85.0  -0.8
! 11.76 GHz  -16.8  -87.8  -84.6  -0.8
! 11.84 GHz  -17.6  -90.0  -84.8  -0.8
! 11.84 GHz  -17.6  -84.6  -85.3  -0.8
! 12 GHz  -19.6  -88.4  -87.7  -0.8
