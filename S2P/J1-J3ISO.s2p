!Agilent Technologies,N5230C,MY49001174,A.09.42.21
!Agilent N5230C: A.09.42.21
!Date: Saturday, January 30, 2016 08:39:21
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   801 points, 8 GHz to 12 GHz, reference 50 ohm
!   highest |S21| = -81.33 dB at 11.93 GHz (marker M1); lowest = -125.3 dB at 9.995 GHz (marker M2)
!   lowest |S11| = -19.5 dB at 8 GHz (marker M3), VSWR 1.24, Z = 42.3 - j6.02 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -1.2 to -0.8 dB; largest |S21 - S12| = 0.00016
!   S11 on the Smith chart (normalised r, x): 8 GHz: 0.85, -0.12; 9.895 GHz: 0.72, +0.11; 10.65 GHz: 0.77, +0.38; 11.12 GHz: 1.02, +0.58; 11.55 GHz: 1.47, +0.49; 12 GHz: 1.59, -0.05
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 8 GHz  -19.5  -97.0  -97.3  -1.0
! 8.27 GHz  -18.3  -99.0  -95.8  -1.1
! 8.67 GHz  -17.9  -96.6  -94.0  -1.2
! 9.335 GHz  -17.0  -98.6  -102.0  -1.2
! 9.605 GHz  -16.3  -107.5  -103.2  -1.2
! 9.895 GHz  -15.2  -99.3  -97.9  -1.2
! 9.995 GHz  -14.8  -125.3  -93.9  -1.2
! 10 GHz  -14.8  -94.3  -99.6  -1.2
! 10.65 GHz  -12.2  -96.8  -86.9  -1.1
! 10.67 GHz  -12.1  -93.6  -90.8  -1.1
! 10.89 GHz  -11.5  -84.6  -84.8  -1.0
! 11.12 GHz  -11.2  -82.3  -85.6  -1.0
! 11.34 GHz  -11.1  -86.5  -83.8  -0.9
! 11.55 GHz  -11.3  -95.4  -84.5  -0.9
! 11.62 GHz  -11.5  -96.4  -85.5  -0.9
! 11.62 GHz  -11.5  -88.8  -97.4  -0.9
! 11.66 GHz  -11.6  -93.0  -82.0  -0.9
! 11.66 GHz  -11.6  -84.1  -89.3  -0.9
! 11.89 GHz  -12.3  -96.0  -83.4  -0.8
! 11.9 GHz  -12.4  -83.5  -87.0  -0.8
! 11.93 GHz  -12.5  -81.3  -85.0  -0.8
! 12 GHz  -12.8  -97.3  -85.2  -0.8
